# IAR project HAC_LCsens.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 SiliconLaboratories EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32TG210F32
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\Device\EFM32TG\Include; ..\emlib\inc; ..\app_uart; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HAC_LCsens.bin
  ILINK.IlinkOutputFile: lcsense.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32TG840F32 SiliconLaboratories EFM32TG840F32
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32TG_STK3300\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: EFM32TG840F32
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lcsense.bin
  group CMSIS
    ../Device/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../Device/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../emlib/src/: em_acmp.c em_cmu.c em_core.c em_dac.c em_dma.c em_emu.c em_gpio.c em_lesense.c em_letimer.c em_leuart.c em_msc.c em_rtc.c em_timer.c em_usart.c em_wdog.c
  group Source
    ../: Agreement.c lcsense.c lcsense_conf.h main.c
    ../app_uart/: app_uart.c dv_uart.c
